# Keil uVision project ICE-GPIOF.uvprojx, settings and files
target ICE-10-GPIOF-Dist (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(80000000) ELITTLE
  output: ece353_base_project
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c misc: --debug
  c include: C:\Keil_v5\ARM\Pack\ARM\CMSIS\3.20.4\CMSIS\Include;..\include;..\drivers\include;..\peripherals\include
  asm misc: --debug
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: main.c
  group lib
    ../lib/: ECE353-Validate.lib
  group peripherals
    ../peripherals/c/: launchpad_io.c
    ../peripherals/include/: launchpad_io.h
  group drivers
    ../drivers/include/: driver_defines.h
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
